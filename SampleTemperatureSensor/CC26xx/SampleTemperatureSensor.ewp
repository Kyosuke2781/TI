# IAR project SampleTemperatureSensor.ewp, settings and files
configuration SmartRF06 (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ZCL_READ; ZCL_WRITE; ZCL_BASIC; ZCL_REPORT; ZCL_IDENTIFY; ZCL_TEMPERATURE_MEASUREMENT; ZCL_EZMODE; xZCL_GROUPS; ZCL_STANDALONE; ZG_SECURE_ENABLED; ewarm; USE_ICALL; HEAPMGR_SIZE=4096; ICALL_HOOK_ABORT_FUNC=halAssertHandler; xdc_runtime_Log_DISABLE_ALL; xdc_runtime_Assert_DISABLE_ALL; MODULE_CC26XX_7X7; TI_DRIVERS_LCD_INCLUDED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f configPkg\compiler.opt.defs; -f ..\..\..\Core\Thread\CC26xx\Config\coreEndDevice.cfg
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\Source; ..\..\..\common\CC26xx; ..\..\..\common\CC26xx\appport; ..\..\..\common\CC26xx\SmartRF06; ..\..\..\..\..\Components\applib\heap; ..\..\..\..\..\Components\mac\include\cc26xx; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\_common\cc26xx; ..\..\..\..\..\Components\hal\target\CC2650\rom; ..\..\..\..\..\Components\hal\target\CC2650TIRTOS; ..\..\..\..\..\Components\icall\include; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\nv; ..\..\..\..\..\Components\services\nv\cc26xx; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\stack\icall; ..\..\..\..\..\Components\stack\icall\client; ..\..\..\..\..\Components\stack\zcl; $DRIVERLIB$/; $DRIVERLIB$/inc; $DRIVERLIB$/driverlib; C:\ti\tirtos_cc13xx_cc26xx_2_21_00_06\products\tidrivers_cc13xx_cc26xx_2_21_00_04; C:\ti\tirtos_cc13xx_cc26xx_2_21_00_06\products\cc26xxware_2_24_03_17272
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SampleTemperatureSensor.srec
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: SampleTemperatureSensor.out
  ILINK.IlinkConfigDefines: CC2650=1; USE_SYSBIOS_IN_ROM=1
  ILINK.IlinkIcfFile: cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f configPkg\linker.cmd; -f ..\..\..\Core\Thread\CC26xx\Config\coreEndDevice.xcl
  ILINK.IlinkAdditionalLibs: $DRIVERLIB$/driverlib/bin/iar/driverlib.lib; ..\..\..\..\..\Projects\common\TIMAC_ROM_Release\03282014\timac_rom_PATCH.symbols
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group ADC
    ADC/: ADC.c ADCCC26XX.c aux_adc.c CC2650DK_7ID.c
  group Application
    ../../../common/CC26xx/SmartRF06/: board_key.c board_lcd.c board_led.c
    ../../../common/CC26xx/: board_key.h board_lcd.h board_led.h util.c util.h zcl_port.c zcl_port.h
    ./: tempsensor.c tempsensor.h znwk_config.h
  group Config
    ./: app.cfg cc26xx_app.icf
    ../../../Core/Thread/CC26xx/Config/: coreEndDevice.cfg coreEndDevice.xcl
  group ICall
    ../../../../../Components/icall/ports/tirtos/: CryptoBoard.c ICall.c ICallCC2650.c ICallPlatform.h
    ../../../../../Components/icall/include/: CryptoBoard.h ICall.h ICallCC26xxDefs.h
    ../../../../../Components/applib/heap/: heapmgr.h
    ./: ICallAddrs.h
  group Services
    ../../../../../Components/services/nv/: nvintf.h
    ../../../../../Components/services/nv/cc26xx/: nvoctp.c nvoctp.h
    ../../../../../Components/hal/target/_common/cc26xx/: pwrmon.c pwrmon.h
  group Startup
    ../../../common/CC26xx/SmartRF06/: Board.c Board.h ccfg.c
    ./: main.c
  group ZCL
    ../../../../../Components/stack/zcl/: zcl.c zcl.h zcl_diagnostic.c zcl_diagnostic.h zcl_ezmode.c zcl_ezmode.h zcl_general.c zcl_general.h zcl_ms.c zcl_ms.h
  group ZStack
    ../../../../../Components/stack/icall/: zstack.h zstackmsg.h
    ../../../../../Components/stack/icall/client/: zstackapi.c zstackapi.h
